v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
T {................................................................................................................................................................
................................................................................................................................................................
................................................................................................................................................................
................................................................................................................................................................
................................................................................................................................................................
................................................................................................................................................................
................................................................................................................................................................
.................................................................... ...........................................................................................
.................................................................-+===---:-:....................................................................................
....................................................:-====-=+***#%#%%##%###%#+++-::.............................................................................
...............................................:---=#*#=#######%%###%#%###%#%%########*=........................................................................
..........................................:=::++#*######%%###%%%#%%%%#%%%%##%####%###*#*-.......................................................................
.......................................:--=++*#*#####%#%%#%%#%%%%%%%####%%%%#%%%##########+-::..................................................................
.......................................-++*#######%%%#%%#%%%%%%%%%%%%%%%%#%###%%###%%##%%%%*=--:................................................................
....................................::--=**######%%%%#%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%#########*-...............................................................
...................................::--+++*##%%%%%%%%%%%%%%##################%%%%%%%%%%%##########-.. ..........................................................
..................................:=+*++*####%%%%%%%######**+++++++++++++++++++**#%%%%%%#######%##*-............................................................
.................................=******#%%%%%%##***++++++++++++++++===++++++++++***#%%%%%%%%%%####*-...........................................................
.............................. .-+*######%%%#**++++++=========+================+=++**##%%%%#%%%%%###*:..........................................................
...............................+#######%%%#*+++++++===============================+++*####%%##%%%%%###:.........................................................
............................ .:+#####%%%#**++++====================================+++*#####%#########=.........................................................
..............................-*####%%%#**++++======================================++**####%%######%##-........................................................
..............................:-+*#%%%%**+++=========================================+++*#*##%#%#######*. ......................................................
...............................=*###%%#*++++==========================================+++*#######%#####*+.......................................................
..............................:+####%#*++++============================================+++***#######***##:......................................................
..............................-*#%##%#*+++==============================================+++**#####%###**#+......................................................
..............................:+#%####*++++===================================+===========++**###########*......................................................
..............................:+#%####**+++==============================+******+***+======+**###%#%%##*#+......................................................
..............................:+#%##*#*++++====================-----=+*##****+++++++++++==+=+*#%%%%#%##*#- .....................................................
..............................:-#%%###**++++==+===========-------==+****+====-====++++++====++=#%%%###**=.......................................................
...............................:=%####***+++++*****###***+===--===++++=========++++++==+=++-=+*#####**+==:......................................................
.................................*%###**++******###***#***+=============++++##%#+++*+=-.++*====*###*+====:......................................................
.................................-###*#***##****+==-=-===++++=======++++++==*##++=====+========+**#++===-.......................................................
..................................+####**#***+=====+=====-=++++===++++=++++============+====++=++***=====:......................................................
..................................:#%%%#********++*###*+=:=-:*+++=++========---=========+====++++*++=----- .....................................................
...................................+#%%%#***+++#%+*###+=+==+-*++===+++==-======+==============+++**+=--===......................................................
................................. ..=***#+**=+*+++====-=-===-+++===+++========================++****+=====......................................................
................................... .=+##**++++============++*++===++++++++++++===========+===++*****=====......................................................
......................................-+#++++++========+==++**+==++===++++======-----=====+===++****+====:......................................................
.......................................=#*++++=====++++++===+++=======++++===+====----====++++++****+===:.......................................................
...................................... :***++=============-=++++=====+##*+++===+++=========++++******=: .. .....................................................
........................................=***+++=====---====+++***+++**+*+++=======++=======++++**##*:.. ........................................................
.........................................****++====----=====++++****+**##**++++**+++====-==++++**##*-...........................................................
........................................ =#**+=====--=======++**####*#%##**#####%###*=---=+++++**##*-...........................................................
........................................ .****++======+==++*####%#*##*##******#######+=--=+++***###*-...........................................................
..........................................-#**++=======**#######**#*++*********+++++=*+-==+=+*+*###*-...........................................................
..........................................:***+++=====+###%###**+++++=====++++++======++=++++**####+:................................. .............. ..........
..........................................:=***+++==-=+*####**++++=+++++*++++++++==++++*++++**####+:. .............................:::::........................
...........................................-****+++=====*++******#+********+=++++==+++++++++*##%#%=: ..............................:---=-::-:::::::...:------===
...........................................:+##*+*++====**+++**++++**#**+++*====+++***++***###%%%#-..................:::..::....::=+****++++++++=-:..:=*********
.......................................... ..+****++++==++*++++++*+**+*+*++*++++++++*******##%%%#*+:.........:-::===-===+++=-:-=++*******#*******-..:-=**######*
............................................ :=***++=*+=+++***+++***#+**+*+*#**++****#***###%%%%##+--==---::-=+++***++***********############*****+==+*####%%##*
...............................................-+##******+**##****###*+=++++*+*****#####*#%%%%%#*++*-=+*****+=+*#######*##**#############################%%%###*
................................................:=###******#*#######**+=++***#######%##%%%%%%%*+++*=--***###****####################%%%%%%###%%%%%%%%%%%%%######
................................................ .=*#%%*#**#%#########**+***##*###%%%%#%%%%#**+++=-=--=###*****#####%####################%%%%%%%%%%%%%#####%####
...................................................=##%%%%#%#%%%%%####%######%#%#%%#%%%%%***+++=-------=#**++*##############################%%%%%%%%%%%%#*#####%
....................................................:*%%%%%%%%%%%#####%##%%%%###%%%%%%%#**+++=----------*##*############################**######################
.................................................... -#%%%%%%%%#%%%%%%%%%##%%##%%%%%%%#*+++--------------*###*#########%%%%%%%%#################################
............................................... . . :++++*#%%%%%%%%%%%%%%%%%%%%%%%%%#*+==----------------=######*###%%%%%%%%%%%########%%%%%%%##%%%%%%%%%%%%%%%%
...................................................*#++++++++*#%%%%%%%%%%%#%%%%%%#*+++=-----------------=-*%######*##%%%%%%%%%%##%%%##%#%%%%%%%%%####%%%%%%%%%%%
........................................... . . .-%#*+++========+*###%%%%#%###**+====---------------------*%%%%#######**#%%%%%%%%%%%%%#%%%%%%%#%%###%###%%%##%##
........................................... .. :##%#*+==============++++++*++==-===----------------------=#%%%%%%%###############%%%%%%%%%%%%%%%%%%%%%%###%%%%%#
............................................ :*#%%%%*+============----===------=------------------------=+%%%%%%%%%%%%%%%###%###########%%%%%%%%%%%#%%%%%%%%%%##
.......................................  ..-####%%%%#++===========------===--===------------------------=#%%%%%%%%%%%%%%%%%%%%%%###%%%%########%%%%#%%%%%%%%%%%%
.....................................  .=######%%%%##*+===============-=+=-=====------------------------+%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%##########%%%%%%%%%%
............................ ....  :*####%##%%%%%%%%%#+=============-=========-------------------------=*%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%##########%%%
............................. :=##%%#%%%#%%%%%%%%%%%%#+===========-===========----::::-----------------=%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%####%####
-=:::......... .. ......  :*#%%%%%%%%%%%%%%%%%%%%%%%%%++=========-=-=+==++==-------:--=++*------------=+%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%#
**=++++=-:.... ...  .:+##%%%%%%%%%##%%%%%%%%%%%%%%%%%%*========-===-+++======----:---=+++==+=---------=#%%%%%%%%%%%%%%%%%##*#%%##%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%
###*##**+=:.....:+####%%%%%%%%%%%%%%#%%%%%%%%%%%%%%%%%#+======-=----=+++=====--:-:--=+++====-==-------=%%%%%%%%%%%%#==%=-++*==--=+#%%%%%%%%%%%%%%%%%%%%%%%%%%%%%
###****#*=::+#####%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%++===-====---==++=====---:-=+++=-=====--------=#%%%%%%%%%%%%#++=-+*++===-=+++%#%%%%%%%%%%%%%%%%%%%%%%%%%%
############%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%#+==-======++=-=***++++=--==+==-----===------=+%%%%%%%%%%#%%%*+++***=+=====+==##*%%%%%%%%%%%%%%%%%%%%%%%%
%#####%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%+=-=--======---**=--===+++**--------==-------*%%%%%%%%%%%%%%%%*=**+++++======:#%#%%#%%%%%%%%%%%%%%%%%%%%
##%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%+==----------=-=--:--=+++**------------------%%%%%%%%%%%%%%%%%%+*#+*+**#+-+*#**#%%%%%%%%%%%%%%%%%%%%%%%%
%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%#==-==------====-:-=+++++++==---------------+%%%%%%%%%%%%%%%%%%%%*#+**#*+*===-##%%#%%%%%%%%%%%%%%%%%%%%%
%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%*====--------=--==+++++======-------------=%%%%%%%%%%%%%%%%%%%%%#*#%####+#%%-**%%%%%%%%%%%%%%%%%%%%%%%%
%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%#======--------=+++==-========-----------=+%%%%%%%%%%%%%%%%%%%#**#%%%%%%%%%%#%##%%%%%%%%%%%%%%%%%%%%%%%
%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%+====--------=++==:--=========---------==#%%%%%%%%%%%%%%%%%%#**#%%%%%%%%%%%%%%%%%%###%%%%%%%%%%%%%%%%%
%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%#+==--------=+==-:---==========---------*%%%%%%%%%%%%%%%%%%#**#%%%%%%%%%%%%%%%#%%#%###%%%%%%%%%%%%%%##
%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%=---------=+=--:-:--===========-------=%%%%%%%%%%%%%%%%%%%##%%%%%%%%%%%%%%%%%%%%%#####%%%%%%%%%%%%%%%
%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%#--------=+=-----:---==========-------#%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%##%%%%%%%%%#%%%%%%%%%%#%%%%
%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%#+-------+=----:::---===========-----=%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%##%%%%%%%%%########%%%%#%#%%%%%%%
%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%##------==------::----==========-----#%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%##%###%%%%%#######%##%%#%#%##%%%%
%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%*-----=------:-------==========---+%#%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%###%%%##%%%%#%%%%%%%#%%#%%%%
%#%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%##=--------------------======++*=--#%#%%%%%%%%%%%%%%%%%%%%%%%%%###%###%#####%#########%%%%%%##%%%%%%
%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%##----------------:----===++++*+-#%%%%%%%%%%%%%%%%%%%%%%%%%%%%%##%%########%#%%#######%%%%%##%%%%%%
%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%##=---------------:----=++++**+++%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%##%########%###%######%%#%%###%%%%%
%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%#--------------::---==++*+++=+%##%#%%%%%%%%%%%%%%%%%%%%%%#######%########%%###%#####%%%%%%##%%%%%
%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%#+--------------::-=++++++===#%%%#%%%%%%%%%%%%%%%%%%%%%%#%%%#################%%%##%#%%%%%%#%%%%%%
%%%%#%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%#-------------:-===++++====+%%%%%%%%%%%%%%%%%%%%%%%%%%%#%####################%%####%%%%%%#%%%%%%
} 2350 -10640 0 0 2 2 {}
